	ORG 0000H
	SJMP START
	ORG 0030H
START:MOV SP,#60H
	  MOV P1,#0FFH

MAIN:CLR P1.0
	 CALL DELAY
	 SETB P1.0
	 CLR P1.1
	 CALL DELAY
	 SETB P1.1
	 CLR P1.2
	 CALL DELAY
	 SETB P1.2
	 CLR P1.3
	 CALL DELAY
	 SETB P1.3
	 CLR P1.4
	 CALL DELAY
	 SETB P1.4
	 CLR P1.5
	 CALL DELAY
	 SETB P1.5
	 CLR P1.6
	 CALL DELAY
	 SETB P1.6
	 CLR P1.7
	 CALL DELAY
	 SETB P1.7
	 SJMP MAIN

DELAY:MOV R0,#250
   D2:MOV R1,#250
   D1:DJNZ R1,D1
      DJNZ R0,D2
	  RET
	  END